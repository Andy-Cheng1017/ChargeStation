# Keil uVision project USBD_HID_Transfer_and_Keyboard.uvproj, settings and files
target USBD_HID_Transfer_and_Keyboard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC121SC2AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: USBD_HID_Transfer_and_Keyboard
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC121\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC121.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC121/Source/: system_NUC121.c
    ../../../../Library/Device/Nuvoton/NUC121/Source/ARM/: startup_NUC121.s
  group User
    ../: descriptors.c main.c HID_Transfer_and_Keyboard.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usbd.c sys.c clk.c gpio.c
